# Keil uVision project FREE-BMS.uvprojx, settings and files
target FREE-BMS (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: FREE-BMS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User;../User/Bms;../User/Bms/Config;../User/Bms/App;../User/Bms/Core;../User/Bms/Hal;../User/Drivers
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group User\Bms\Config
    ../User/Bms/Config/: bms_config.h
  group User\Bms\App
    ../User/Bms/App/: bms_init.c bms_init.h bms_sample_task.c bms_sample_task.h bms_alert_task.c bms_alert_task.h bms_uart_cmd.c bms_uart_cmd.h bms_can_task.c bms_can_task.h
  group User\Bms\Core
    ../User/Bms/Core/: bms_monitor.c bms_monitor.h bms_protect.c bms_protect.h bms_control.c bms_control.h bms_energy.c bms_energy.h bms_analysis.c bms_analysis.h bms_log.c bms_log.h
  group User\Bms\Hal
    ../User/Bms/Hal/: bms_hal_monitor.c bms_hal_monitor.h bms_hal_config.h bms_hal_watchdog.c bms_hal_watchdog.h
  group User\Drivers
    ../User/Drivers/: drv_soft_i2c.c drv_soft_i2c.h drv_softi2c_bq769x0.c drv_softi2c_bq769x0.h
software components: CMSIS:CORE 4.3.0
